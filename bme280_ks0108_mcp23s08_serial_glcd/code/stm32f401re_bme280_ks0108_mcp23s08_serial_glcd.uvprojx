# Keil uVision project stm32f401re_bme280_ks0108_mcp23s08_serial_glcd.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506_Windows_x86_b960)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f401re_bme280_ks0108_mcp23s08_serial_glcd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
    ./assets/gpio/: gpio_c.h gpio_h.h
    ./assets/delay/: delay_c.h
    ./assets/ks0108/: ks0108_c.h ks0108_h.h charset.h image.h
    ./assets/bme280/: bme280_c.h bme280_h.h
    ./assets/spi/: soft_spi.h
    ./assets/mcp23s08/: mcp23s08_c.h mcp23s08_h.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
