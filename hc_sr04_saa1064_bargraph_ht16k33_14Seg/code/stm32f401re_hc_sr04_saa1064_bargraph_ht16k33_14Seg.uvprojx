# Keil uVision project stm32f401re_hc_sr04_saa1064_bargraph_ht16k33_14Seg.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506_Windows_x86_b960)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f401re_hc_sr04_saa1064_bargraph_ht16k33_14Seg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c
    ./assets/gpio/: gpio_c.h gpio_h.h
    ./assets/delay/: delay_c.h
    ./assets/ht16k33/: ht16k33_c.h ht16k33_h.h charset.h
    ./assets/i2c/: soft_i2c.h
    ./assets/hc_sr04/: hc_sr04_c.h hc_sr04_h.h
    ./assets/saa1064/: saa1064_c.h saa1064_h.h
    ./assets/bargraph/: bargraph_c.h bargraph_h.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
